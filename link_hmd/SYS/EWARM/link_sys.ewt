<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f412rx.s</name>
      </file>
    </group>
    <group>
      <name>Fusion</name>
      <file>
        <name>$PROJ_DIR$\..\Fusion\GyroscopeBiasEstimator.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fusion\HeadTracker.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fusion\HeadTransform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fusion\LowPassFilter.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fusion\Matrix.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fusion\Matrix3x3d.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fusion\OrientationEKF.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fusion\So3Util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Fusion\Vector3d.c</name>
      </file>
    </group>
    <group>
      <name>MyFusion</name>
      <group>
        <name>utils</name>
        <file>
          <name>$PROJ_DIR$\..\MyFusion\utils\mat.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MyFusion\utils\mymath.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MyFusion\utils\quat.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\MyFusion\utils\vec.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\MyFusion\fusion.c</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <file>
        <name>$PROJ_DIR$\..\Src\fota_command.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\freertos.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\freertos_trace.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\myprintf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\sensor_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_hal_timebase_TIM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\sys_header.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usb_device.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usbd_comp_if.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usbd_conf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usbd_desc.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>BSP</name>
      <group>
        <name>audio</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\audio\audio_alc4040_driver.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\audio\audio_alc5665_driver.c</name>
        </file>
      </group>
      <group>
        <name>Components</name>
        <group>
          <name>akm099xx</name>
          <group>
            <name>AKM_HAL</name>
            <file>
              <name>$PROJ_DIR$\..\Drivers\BSP\Components\akm099xx\AKM_HAL\AKH_APIs.c</name>
            </file>
          </group>
          <group>
            <name>AKM_Library</name>
            <group>
              <name>common</name>
              <file>
                <name>$PROJ_DIR$\..\Drivers\BSP\Components\akm099xx\AKM_Library\common\akl_lib_func.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\Drivers\BSP\Components\akm099xx\AKM_Library\common\akl_nonos_ext.c</name>
              </file>
            </group>
            <group>
              <name>lib3d</name>
              <file>
                <name>$PROJ_DIR$\..\Drivers\BSP\Components\akm099xx\AKM_Library\lib3d\akl_apis.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\Drivers\BSP\Components\akm099xx\AKM_Library\lib3d\measure.c</name>
              </file>
            </group>
            <group>
              <name>libSmartCompass</name>
              <file>
                <name>$PROJ_DIR$\..\Drivers\BSP\Components\akm099xx\AKM_Library\libSmartCompass\ak09916_lib.a</name>
              </file>
            </group>
          </group>
          <group>
            <name>AKM_Sensors</name>
            <file>
              <name>$PROJ_DIR$\..\Drivers\BSP\Components\akm099xx\AKM_Sensors\AKS_APIs.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Drivers\BSP\Components\akm099xx\AKM_Sensors\aks_common.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\Drivers\BSP\Components\akm099xx\AKM_Sensors\aks_mag_ak099xx.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\akm099xx\AKM099XX_MAG_driver_HL.c</name>
          </file>
        </group>
        <group>
          <name>bmi160</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\bmi160\BMI160_ACC_GYRO_Driver.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\bmi160\BMI160_ACC_GYRO_Driver_Api.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\bmi160\BMI160_ACC_GYRO_Driver_HL.c</name>
          </file>
        </group>
        <group>
          <name>CCGx</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\ccgx\ccgx_ccg4.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\ccgx\ccgx_ec.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\ccgx\ccgx_fw.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\ccgx\ccgx_fw_io.c</name>
          </file>
        </group>
        <group>
          <name>ePL88051</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\ePL88051\epl88051_driver.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\ePL88051\EPL88051_PROXIMITY_driver_HL.c</name>
          </file>
        </group>
        <group>
          <name>gSensorCommon</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\gSensorCommon\gSensor_Calibate.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\gSensorCommon\gSensor_Command.c</name>
          </file>
        </group>
        <group>
          <name>LSM6DSM</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\LSM6DSM\LSM6DSM_ACC_GYRO_driver.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\LSM6DSM\LSM6DSM_ACC_GYRO_driver_HL.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\LSM6DSM\SensorTile.c</name>
          </file>
        </group>
        <group>
          <name>yas537</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\yas537\YAS537_MAG_driver_HL.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\yas537\yas_algo.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\yas537\yas_drv.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\yas537\yas_mag_calib_min.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\yas537\yas_mag_drv-yas537.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\Components\yas537\yas_mag_filter.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>display</name>
        <group>
          <name>dp2hdmi</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\display\anx\anx7737.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\display\dp2hdmi\anx7737_driver.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\display\dp2hdmi\ps176_driver.c</name>
          </file>
        </group>
        <group>
          <name>hdmi2dsi</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\display\hdmi2dsi\tc358870xbg_driver.c</name>
          </file>
        </group>
        <group>
          <name>mipi_scaling</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\display\mipi_scaling\px8468wm.c</name>
          </file>
        </group>
        <group>
          <name>panel</name>
          <file>
            <name>$PROJ_DIR$\..\Drivers\BSP\display\panel\ams361ep01_dsi_vdo.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\display\display_drv.c</name>
        </file>
      </group>
      <group>
        <name>flash</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\flash\flash_drv.c</name>
        </file>
      </group>
      <group>
        <name>gpio</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\gpio\gpio.c</name>
        </file>
      </group>
      <group>
        <name>I2C</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\I2C\rtos_i2c_drv.c</name>
        </file>
      </group>
      <group>
        <name>IOEXP</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\IO_EXP\gpio_exp.c</name>
        </file>
      </group>
      <group>
        <name>key</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\key_drv\key_drv.c</name>
        </file>
      </group>
      <group>
        <name>led</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\led\led_drv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\led\led_hal.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\led\leds-lp5562.c</name>
        </file>
      </group>
      <group>
        <name>misc_data</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\misc_data\misc_data.c</name>
        </file>
      </group>
      <group>
        <name>power</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\power\bq2589x_charger.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\power\htc_adc_func.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\power\max17050_fuel_gauge.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\power\ncp6924.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\power\periph_multiple_drv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\power\x_pmic.c</name>
        </file>
      </group>
      <group>
        <name>RTC</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\RTC\rtc_drv.c</name>
        </file>
      </group>
      <group>
        <name>uart_drv</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\uart_drv\usart_drv.c</name>
        </file>
      </group>
      <group>
        <name>X_NUCLEO_IKS01A1</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_accelero.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_gyro.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_magneto.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\BSP\X_NUCLEO_IKS01A1\x_nucleo_iks01a1_proximity.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>STM32F4xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ramfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_i2c_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pcd_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_wwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_usb.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Middlewares</name>
    <group>
      <name>3dof_transfer_service</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\htc_3dof_transfer_service\htc_3dof_transfer_service.c</name>
      </file>
    </group>
    <group>
      <name>AudioPathService</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\AudioPathService\htc_audio_path_service.c</name>
      </file>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
      </file>
    </group>
    <group>
      <name>FreeRTOS</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS\cmsis_os.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\croutine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\event_groups.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang\heap_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F\portasm.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\tasks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\Third_Party\FreeRTOS\Source\timers.c</name>
      </file>
    </group>
    <group>
      <name>hlog</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\hlog\hlog_api.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\hlog\hlog_excep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\hlog\hlog_inc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\hlog\hlog_main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\hlog\hlog_main.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\hlog\hlog_test.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\hlog\hlog_utils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\hlog\hlog_utils.h</name>
      </file>
    </group>
    <group>
      <name>htc_usb_cdc_data_services</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\htc_usb_cdc_data_services\htc_usb_cdc_data_service.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\htc_usb_cdc_data_services\system_command.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\htc_usb_cdc_data_services\system_property.c</name>
      </file>
    </group>
    <group>
      <name>PowerManager</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\PowerManager\PowerManager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\PowerManager\PowerManager_battery.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\PowerManager\PowerManager_command.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\PowerManager\PowerManager_notify_func.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\PowerManager\PowerManager_peripherals.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\PowerManager\PowerManager_power.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\PowerManager\PowerManager_state_machine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\PowerManager\PowerManager_system.c</name>
      </file>
    </group>
    <group>
      <name>proximity</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\proximity\proximity_task.c</name>
      </file>
    </group>
    <group>
      <name>shell</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\shell\command.c</name>
      </file>
    </group>
    <group>
      <name>STM32_USB_Device_Library</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Class\COMP\Src\usbd_comp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Core\Src\usbd_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Core\Src\usbd_ctlreq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\ST\STM32_USB_Device_Library\Core\Src\usbd_ioreq.c</name>
      </file>
    </group>
  </group>
</project>


