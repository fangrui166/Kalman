# IAR project link_sys.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F412ZG ST STM32F412ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F412Rx; HTC_TRACE_DEBUG; MVR_DEBUG_BUILD; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Middlewares/PowerManager; ../Drivers/BSP/Include; ../Middlewares/Include; ..\Drivers\BSP\X_NUCLEO_IKS01A1; ..\Drivers\BSP\Components\Common; ..\Drivers\BSP\Components\ePL88051; ..\Middlewares\proximity; ..\Drivers\BSP\Components\LSM6DSM; ..\Middlewares\ST\STM32_USB_Device_Library\Class\COMP\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Drivers\BSP\Components\akm099xx; ..\Drivers\BSP\Components\akm099xx\AKM_HAL; ..\Drivers\BSP\Components\akm099xx\AKM_Library; ..\Middlewares\hlog; ..\Drivers\BSP\Components\akm099xx\AKM_Sensors; ..\Drivers\BSP\Components\yas537; ..\Drivers\BSP\Components\bmi160; ..\Middlewares\ST\STM32_USB_Device_Library\Class\COMP\Inc; ..\Drivers\BSP\display\inc\common; ..\Drivers\BSP\display\inc; ..\Drivers\BSP\flash; ..\Drivers\BSP\RTC; ..\Drivers\BSP\misc_data; ..\Drivers\BSP\Components\gSensorCommon; ../MyFusion\utils; ../MyFusion
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: link_sys.bin
  ILINK.IlinkOutputFile: link.out
  ILINK.IlinkIcfFile: stm32f412rx_flash.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F412Rx; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Middlewares/PowerManager; ../Drivers/BSP/Include; ../Middlewares/Include; ..\Drivers\BSP\Components\Common; ..\Drivers\BSP\Components\ePL88051; ..\Middlewares\proximity; ..\Drivers\BSP\X_NUCLEO_IKS01A1; ..\Drivers\BSP\Components\LSM6DSM; ..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\Drivers\BSP\Components\akm099xx; ..\Drivers\BSP\Components\akm099xx\AKM_HAL; ..\Drivers\BSP\Components\akm099xx\AKM_Library; ..\Middlewares\hlog; ..\Drivers\BSP\Components\akm099xx\AKM_Sensors; ..\Drivers\BSP\Components\yas537; ..\Middlewares\htc_3dof_transfer_service; ..\Drivers\BSP\Components\bmi160; ..\Middlewares\ST\STM32_USB_Device_Library\Class\COMP\Inc; ..\Drivers\BSP\display\inc\common; ..\Drivers\BSP\display\inc; ..\Drivers\BSP\flash; ..\Drivers\BSP\RTC; ..\Drivers\BSP\misc_data; ..\Drivers\BSP\Components\gSensorCommon; ../MyFusion\utils; ../MyFusion
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f412rx.s
  group Application/Fusion
    ../Fusion/: GyroscopeBiasEstimator.c HeadTracker.c HeadTransform.c LowPassFilter.c Matrix.c Matrix3x3d.c OrientationEKF.c So3Util.c Vector3d.c
  group Application/MyFusion
    ../MyFusion/: fusion.c
  group Application/MyFusion/utils
    ../MyFusion/utils/: mat.c mymath.c quat.c vec.c
  group Application/User
    ../Src/: fota_command.c freertos.c freertos_trace.c main.c myprintf.c sensor_task.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c sys_header.c usb_device.c usbd_comp_if.c usbd_conf.c usbd_desc.c
  group Drivers/BSP/audio
    ../Drivers/BSP/audio/: audio_alc4040_driver.c audio_alc5665_driver.c
  group Drivers/BSP/Components/akm099xx
    ../Drivers/BSP/Components/akm099xx/: AKM099XX_MAG_driver_HL.c
  group Drivers/BSP/Components/akm099xx/AKM_HAL
    ../Drivers/BSP/Components/akm099xx/AKM_HAL/: AKH_APIs.c
  group Drivers/BSP/Components/akm099xx/AKM_Library/common
    ../Drivers/BSP/Components/akm099xx/AKM_Library/common/: akl_lib_func.c akl_nonos_ext.c
  group Drivers/BSP/Components/akm099xx/AKM_Library/lib3d
    ../Drivers/BSP/Components/akm099xx/AKM_Library/lib3d/: akl_apis.c measure.c
  group Drivers/BSP/Components/akm099xx/AKM_Library/libSmartCompass
    ../Drivers/BSP/Components/akm099xx/AKM_Library/libSmartCompass/: ak09916_lib.a
  group Drivers/BSP/Components/akm099xx/AKM_Sensors
    ../Drivers/BSP/Components/akm099xx/AKM_Sensors/: AKS_APIs.c aks_common.c aks_mag_ak099xx.c
  group Drivers/BSP/Components/bmi160
    ../Drivers/BSP/Components/bmi160/: BMI160_ACC_GYRO_Driver.c BMI160_ACC_GYRO_Driver_Api.c BMI160_ACC_GYRO_Driver_HL.c
  group Drivers/BSP/Components/CCGx
    ../Drivers/BSP/Components/ccgx/: ccgx_ccg4.c ccgx_ec.c ccgx_fw.c ccgx_fw_io.c
  group Drivers/BSP/Components/ePL88051
    ../Drivers/BSP/Components/ePL88051/: epl88051_driver.c EPL88051_PROXIMITY_driver_HL.c
  group Drivers/BSP/Components/gSensorCommon
    ../Drivers/BSP/Components/gSensorCommon/: gSensor_Calibate.c gSensor_Command.c
  group Drivers/BSP/Components/LSM6DSM
    ../Drivers/BSP/Components/LSM6DSM/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver_HL.c SensorTile.c
  group Drivers/BSP/Components/yas537
    ../Drivers/BSP/Components/yas537/: YAS537_MAG_driver_HL.c yas_algo.c yas_drv.c yas_mag_calib_min.c yas_mag_drv-yas537.c yas_mag_filter.c
  group Drivers/BSP/display
    ../Drivers/BSP/display/: display_drv.c
  group Drivers/BSP/display/dp2hdmi
    ../Drivers/BSP/display/anx/: anx7737.c
    ../Drivers/BSP/display/dp2hdmi/: anx7737_driver.c ps176_driver.c
  group Drivers/BSP/display/hdmi2dsi
    ../Drivers/BSP/display/hdmi2dsi/: tc358870xbg_driver.c
  group Drivers/BSP/display/mipi_scaling
    ../Drivers/BSP/display/mipi_scaling/: px8468wm.c
  group Drivers/BSP/display/panel
    ../Drivers/BSP/display/panel/: ams361ep01_dsi_vdo.c
  group Drivers/BSP/flash
    ../Drivers/BSP/flash/: flash_drv.c
  group Drivers/BSP/gpio
    ../Drivers/BSP/gpio/: gpio.c
  group Drivers/BSP/I2C
    ../Drivers/BSP/I2C/: rtos_i2c_drv.c
  group Drivers/BSP/IOEXP
    ../Drivers/BSP/IO_EXP/: gpio_exp.c
  group Drivers/BSP/key
    ../Drivers/BSP/key_drv/: key_drv.c
  group Drivers/BSP/led
    ../Drivers/BSP/led/: led_drv.c led_hal.c leds-lp5562.c
  group Drivers/BSP/misc_data
    ../Drivers/BSP/misc_data/: misc_data.c
  group Drivers/BSP/power
    ../Drivers/BSP/power/: bq2589x_charger.c htc_adc_func.c max17050_fuel_gauge.c ncp6924.c periph_multiple_drv.c x_pmic.c
  group Drivers/BSP/RTC
    ../Drivers/BSP/RTC/: rtc_drv.c
  group Drivers/BSP/uart_drv
    ../Drivers/BSP/uart_drv/: usart_drv.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_proximity.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_usb.c
  group Middlewares/3dof_transfer_service
    ../Middlewares/htc_3dof_transfer_service/: htc_3dof_transfer_service.c
  group Middlewares/AudioPathService
    ../Middlewares/AudioPathService/: htc_audio_path_service.c
  group Middlewares/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/hlog
    ../Middlewares/hlog/: hlog_api.h hlog_excep.c hlog_inc.h hlog_main.c hlog_main.h hlog_test.c hlog_utils.c hlog_utils.h
  group Middlewares/htc_usb_cdc_data_services
    ../Middlewares/htc_usb_cdc_data_services/: htc_usb_cdc_data_service.c system_command.c system_property.c
  group Middlewares/PowerManager
    ../Middlewares/PowerManager/: PowerManager.c PowerManager_battery.c PowerManager_command.c PowerManager_notify_func.c PowerManager_peripherals.c PowerManager_power.c PowerManager_state_machine.c PowerManager_system.c
  group Middlewares/proximity
    ../Middlewares/proximity/: proximity_task.c
  group Middlewares/shell
    ../Middlewares/shell/: command.c
  group Middlewares/STM32_USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/COMP/Src/: usbd_comp.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
