<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f412rx.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <file>
        <name>$PROJ_DIR$\..\Src\dfuTask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\GLOBAL.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\hlog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\i2c_drv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\initTask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\myprintf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\shellTask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\usart_drv.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>audio</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\audio\audio_alc4040_driver.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\audio\audio_alc5665_driver.c</name>
      </file>
    </group>
    <group>
      <name>ccgx</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ccgx\ccgx_fw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\ccgx\ccgx_fw_io.c</name>
      </file>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
      </file>
    </group>
    <group>
      <name>display</name>
      <group>
        <name>dp2hdmi</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\display\dp2hdmi\anx7737_driver.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Drivers\display\dp2hdmi\ps176_driver.c</name>
        </file>
      </group>
      <group>
        <name>hdmi2dsi</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\display\hdmi2dsi\tc358870xbg_driver.c</name>
        </file>
      </group>
      <group>
        <name>panel</name>
        <file>
          <name>$PROJ_DIR$\..\Drivers\display\panel\ams361ep01_dsi_vdo.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Drivers\display\display_drv.c</name>
      </file>
    </group>
    <group>
      <name>flash</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\flash\flash_drv.c</name>
      </file>
    </group>
    <group>
      <name>fota</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\fota\bl_header.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\fota\fotamode.c</name>
      </file>
    </group>
    <group>
      <name>gpio</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\gpio\gpio.c</name>
      </file>
    </group>
    <group>
      <name>gsensor</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\gsensor\BMI160_ACC_GYRO_Driver.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\gsensor\BMI160_ACC_GYRO_Driver_HL.c</name>
      </file>
    </group>
    <group>
      <name>io_exp</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\io_exp\gpio_exp.c</name>
      </file>
    </group>
    <group>
      <name>misc_data</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\misc_data\misc_data.c</name>
      </file>
    </group>
    <group>
      <name>power</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\power\bq2589x_charger.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\power\max17050_fuel_gauge.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\power\ncp6924.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\power\x_pmic.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ramfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_i2c_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pcd_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_usb.c</name>
      </file>
    </group>
    <group>
      <name>usb_dfu</name>
      <file>
        <name>$PROJ_DIR$\..\Drivers\usb_dfu\src\usb_device_bl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\usb_dfu\src\usbd_conf_bl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\usb_dfu\src\usbd_core_bl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\usb_dfu\src\usbd_ctlreq_bl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\usb_dfu\src\usbd_desc_bl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\usb_dfu\src\usbd_dfu_bl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\usb_dfu\src\usbd_dfu_if_bl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Drivers\usb_dfu\src\usbd_ioreq_bl.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Middlewares</name>
    <group>
      <name>AudioPathService</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\AudioPathService\htc_audio_path_service.c</name>
      </file>
    </group>
    <group>
      <name>PowerManager</name>
      <file>
        <name>$PROJ_DIR$\..\Middlewares\PowerManager\PowerManager_power.c</name>
      </file>
    </group>
  </group>
</project>


