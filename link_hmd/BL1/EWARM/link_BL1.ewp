# IAR project link_BL1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F412ZG ST STM32F412ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F412Rx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Include; ../Drivers/flash; ../Drivers/usb_dfu/inc; ../Middlewares\ST\STM32_USB_Device_Library\Class\DFU\Inc; ../Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ../Drivers\fota; ../Drivers/misc_data; ..\Drivers\gsensor; ..\Drivers\display\inc\common; ..\Drivers\display\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: link_BL1.bin
  ILINK.IlinkOutputFile: link.out
  ILINK.IlinkIcfFile: stm32f412rx_flash_sram.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Include; ../Drivers/flash; ../Drivers/usb_dfu/inc; ../Middlewares\ST\STM32_USB_Device_Library\Class\DFU\Inc; ../Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ../Drivers\fota; ..\Drivers\misc_data; ..\Drivers\gsensor; ..\Drivers\display\inc; ..\Drivers\display\inc\common
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f412rx.s
  group Application/User
    ../Src/: dfuTask.c GLOBAL.c hlog.c i2c_drv.c init.c initTask.c main.c myprintf.c shellTask.c stm32f4xx_hal_msp.c stm32f4xx_it.c task.c usart_drv.c
  group Drivers/audio
    ../Drivers/audio/: audio_alc4040_driver.c audio_alc5665_driver.c
  group Drivers/ccgx
    ../Drivers/ccgx/: ccgx_fw.c ccgx_fw_io.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/display
    ../Drivers/display/: display_drv.c
  group Drivers/display/dp2hdmi
    ../Drivers/display/dp2hdmi/: anx7737_driver.c ps176_driver.c
  group Drivers/display/hdmi2dsi
    ../Drivers/display/hdmi2dsi/: tc358870xbg_driver.c
  group Drivers/display/panel
    ../Drivers/display/panel/: ams361ep01_dsi_vdo.c
  group Drivers/flash
    ../Drivers/flash/: flash_drv.c
  group Drivers/fota
    ../Drivers/fota/: bl_header.c fotamode.c
  group Drivers/gpio
    ../Drivers/gpio/: gpio.c
  group Drivers/gsensor
    ../Drivers/gsensor/: BMI160_ACC_GYRO_Driver.c BMI160_ACC_GYRO_Driver_HL.c
  group Drivers/io_exp
    ../Drivers/io_exp/: gpio_exp.c
  group Drivers/misc_data
    ../Drivers/misc_data/: misc_data.c
  group Drivers/power
    ../Drivers/power/: bq2589x_charger.c max17050_fuel_gauge.c ncp6924.c x_pmic.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Drivers/usb_dfu
    ../Drivers/usb_dfu/src/: usb_device_bl.c usbd_conf_bl.c usbd_core_bl.c usbd_ctlreq_bl.c usbd_desc_bl.c usbd_dfu_bl.c usbd_dfu_if_bl.c usbd_ioreq_bl.c
  group Middlewares/AudioPathService
    ../Middlewares/AudioPathService/: htc_audio_path_service.c
  group Middlewares/PowerManager
    ../Middlewares/PowerManager/: PowerManager_power.c
